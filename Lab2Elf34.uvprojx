# Keil uVision project Lab2Elf34.uvprojx, settings and files
target EK-TM4C1294XL (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab02 +hex
  AfterMake: fromelf.exe --bin Objects\Lab01.axf --output Objects\Lab01.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\TivaWare_C_Series-2.2.0.295;C:.\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source
    ./: main.c
    ../TivaWare_C_Series-2.2.0.295/examples/boards/ek-tm4c1294xl/blinky/: startup_rvmdk.S
  group Libraries
    ../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ./: images.c
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.5.0
